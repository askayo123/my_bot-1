Commit message: 1

File: description/camera.xacro (robot description, xacro)
@@ -9,5 +9,5 @@
         <visual>
             <geometry>
-                <box size="0.1 0.03 0.03"/>
+                <box size="0.04 0.03 0.03"/>
             </geometry>
             <material name="red"/>
